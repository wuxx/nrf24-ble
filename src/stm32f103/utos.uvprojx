# Keil uVision project utos.uvprojx, settings and files
target utos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: utos +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\include;.\system;.\driver\usb;.\driver\usb\lib;.\driver\usb\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group system
    ./system/: main.c int.c common.c
  group driver
    ./driver/gpio/: gpio.c
    ./driver/log/: log.c
    ./driver/uart/: uart.c
    ./driver/watchdog/: watchdog.c
    ./driver/shell/: shell.c
    ./driver/dma/: dma.c
    ./driver/flash/: flash.c
    ./driver/timer/: timer.c
    ./driver/dht11/: dht11.c
    ./driver/ds18b20/: ds18b20.c
    ./driver/hcsr04/: hcsr04.c
    ./driver/i2c_test/: bmp180.c
    ./driver/systick/: systick.c
    ./: gt911.c
    ./driver/spi/: spi.c
    ./driver/nrf24l01/: nrf24l01.c
  group test
    ./test/: systest.c test_dma.c test_flash.c test_gpio.c test_log.c test_timer.c
  group usb
    ./driver/usb/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ./driver/usb/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
    ./driver/usb/: queue.c
software components: CMSIS:CORE 5.1.2, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
